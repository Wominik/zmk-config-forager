## config/boards/shields/forager_central_dongle/Kconfig.shield
```kconfig
config SHIELD_FORAGER_CENTRAL_DONGLE
    def_bool $(shields_list_contains,forager_central_dongle)
```
